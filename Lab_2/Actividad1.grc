options:
  parameters:
    generate_options: qt_gui
    id: ModuladorFMRX
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: D
  id: variable
  parameters:
    value: '25'
  states: {}
- name: GRX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del transmisor
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de la Portadora
    start: '88000000'
    step: '100000'
    stop: '108000000'
    value: '96900000'
  states: {}
- name: fcb
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de corte filtro
    start: '10000'
    step: '100'
    stop: '100000'
    value: '100000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '6250000'
  states: {}
- name: analog_fm_preemph_0
  id: analog_fm_preemph
  parameters:
    fh: '-1.0'
    samp_rate: samp_rate/D
    tau: '75e-6'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: samp_rate/D
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      class blk (gr. sync_block ):
      	def __init__ ( self ) : # only default arguments here
      		gr. sync_block . __init__ (
      		self ,
      		name = "Promedios_de_tiempos", # will show up in GRC
      		in_sig =[ np. float32 ],
      		out_sig =[ np. float32 ,np. float32 ,np. float32 ,np. float32 ,np. float32 ]
      		)
      		self . acum_anterior = 0
      		self . Ntotales = 0
      		self . acum_anterior1 = 0
      		self . acum_anterior2 = 0
      	def work (self , input_items , output_items ):
      		x = input_items [0] # Senial de entrada .
      		y0 = output_items [0] # Promedio de la senial
      		y1 = output_items [1] # Media de la senial
      		y2 = output_items [2] # RMS de la senial
      		y3 = output_items [3] # Potencia promedio de la senial
      		y4 = output_items [4] # Desviacion estandar de la senial
      		
      		# Calculo del promedio
      		N = len (x)
      		self . Ntotales = self . Ntotales + N
      		acumulado = self . acum_anterior + np. cumsum (x)
      		self . acum_anterior = acumulado [N -1]
      		y0 [:]= acumulado / self . Ntotales
      		
      		# Calculo de la media cuadratica
      		x2=np. multiply (x,x)
      		acumulado1 = self . acum_anterior1 + np. cumsum (x2)
      		self . acum_anterior1 = acumulado1 [N -1]
      		y1 [:] = acumulado1 / self . Ntotales
      		
      		# Calculo de la RMS
      		y2 [:] = np. sqrt (y1)
      		
      		# Calculo de la potencia promedio
      		y3 [:] = np. multiply (y2 ,y2)
      		# Calculo de la desviacion estandar
      		x3 = np. multiply (x-y0 ,x-y0)
      		acumulado2 = self . acum_anterior2 + np. cumsum (x3)
      		self . acum_anterior2 = acumulado2 [N -1]

      		y4 [:] = np. sqrt ( acumulado2 / self . Ntotales )
      		return len(x)
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: fcb
    decim: D
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '8192'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/D
    fc: '0'
    fftsize: '8192'
    nconnections: '2'
    type: float
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: Promedio
    label2: 'Media '
    label3: RMS
    label4: Potencia
    label5: Desviacion Estandar
    nconnections: '5'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/D)
    interp: '44100'
    type: fff
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: fc
    gain0: '0'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_fm_preemph_0, '0', qtgui_freq_sink_x_1, '1']
- [analog_fm_preemph_0, '0', rational_resampler_xxx_0, '0']
- [analog_wfm_rcv_0, '0', analog_fm_preemph_0, '0']
- [analog_wfm_rcv_0, '0', epy_block_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_1, '0']
- [epy_block_0, '0', qtgui_number_sink_0, '0']
- [epy_block_0, '1', qtgui_number_sink_0, '1']
- [epy_block_0, '2', qtgui_number_sink_0, '2']
- [epy_block_0, '3', qtgui_number_sink_0, '3']
- [epy_block_0, '4', qtgui_number_sink_0, '4']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_1, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.8.0
