options:
  parameters:
    author: labcom
    generate_options: qt_gui
    id: Lab2_1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: samp_rate
    start: '10'
    step: '60'
    stop: '1000'
    value: '10'
  states: {state: disabled}
- name: samp_rate_0
  id: variable_qtgui_range
  parameters:
    label: samp_rate
    start: '0'
    step: '10000'
    stop: '250000'
    value: '195312'
  states: {}
- name: E3TRadio_sumador_0
  id: E3TRadio_sumador
  parameters: {}
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '60'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: b_noise_dB_f_0
  id: b_noise_dB_f
  parameters:
    NodB: '0'
    samp_rate: '1'
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: (1, 2, -1)
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      class blk (gr. sync_block ):
      	def __init__ ( self ) : # only default arguments here
      		gr. sync_block . __init__ (
      		self ,
      		name = "Promedios_de_tiempos", # will show up in GRC
      		in_sig =[ np. float32 ],
      		out_sig =[ np. float32 ,np. float32 ,np. float32 ,np. float32 ,np. float32 ]
      		)
      		self . acum_anterior = 0
      		self . Ntotales = 0
      		self . acum_anterior1 = 0
      		self . acum_anterior2 = 0
      	def work (self , input_items , output_items ):
      		x = input_items [0] # Senial de entrada .
      		y0 = output_items [0] # Promedio de la senial
      		y1 = output_items [1] # Media de la senial
      		y2 = output_items [2] # RMS de la senial
      		y3 = output_items [3] # Potencia promedio de la senial
      		y4 = output_items [4] # Desviacion estandar de la senial
      		
      		# Calculo del promedio
      		N = len (x)
      		self . Ntotales = self . Ntotales + N
      		acumulado = self . acum_anterior + np. cumsum (x)
      		self . acum_anterior = acumulado [N -1]
      		y0 [:]= acumulado / self . Ntotales
      		
      		
      		# Calculo de la media cuadratica
      		x2=np. multiply (x,x)
      		acumulado1 = self . acum_anterior1 + np. cumsum (x2)
      		self . acum_anterior1 = acumulado1 [N -1]
      		y1 [:] = acumulado1 / self . Ntotales
      		
      		
      		# Calculo de la RMS
      		y2 [:] = np. sqrt (y1)
      		
      		
      		# Calculo de la potencia promedio
      		y3 [:] = np. multiply (y2 ,y2)
      		
      		
      		# Calculo de la desviacion estandar
      		x3 = np. multiply (x-y0 ,x-y0)
      		acumulado2 = self . acum_anterior2 + np. cumsum (x3)
      		self . acum_anterior2 = acumulado2 [N -1]
      		
      		y4 [:] = np. sqrt ( acumulado2 / self . Ntotales )
      		return len(x)
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: Media
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: Media cuadratica
    type: float
  states: {}
- name: qtgui_number_sink_0_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: RMS
    type: float
  states: {}
- name: qtgui_number_sink_0_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: Desviacion estandar
    type: float
  states: {}
- name: qtgui_number_sink_0_3
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: Potencia promedio
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: '0'
    gain0: '0'
    samp_rate: samp_rate_0
    sync: sync
    type: fc32
  states: {}

connections:
- [E3TRadio_sumador_0, '0', epy_block_0, '0']
- [analog_sig_source_x_0, '0', epy_block_0, '0']
- [analog_sig_source_x_0, '0', qtgui_sink_x_0, '0']
- [b_noise_dB_f_0, '0', E3TRadio_sumador_0, '1']
- [epy_block_0, '0', qtgui_number_sink_0, '0']
- [epy_block_0, '1', qtgui_number_sink_0_0, '0']
- [epy_block_0, '2', qtgui_number_sink_0_1, '0']
- [epy_block_0, '3', qtgui_number_sink_0_3, '0']
- [epy_block_0, '4', qtgui_number_sink_0_2, '0']

metadata:
  file_format: 1
  grc_version: 3.9.8.0
